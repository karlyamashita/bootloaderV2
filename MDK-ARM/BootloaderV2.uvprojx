# Keil uVision project BootloaderV2.uvprojx, settings and files
target Bootloader0x8008000 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F105RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x801FFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: Bootloader +hex
  c flags: OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F105xC, BOOTLOADER_ADDRESS0x8008000
  c misc: --C99
  c include: ../Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Middlewares/ST/STM32_USB_Device_Library/Core/Inc;../Middlewares/ST/STM32_USB_Device_Library/Class/CustomHID/Inc;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;..\..\..\..\Dropbox\Crux Projects\CommonLibraries
  library: MicroLIB
  memory RVCT1: ROM 0x8007800 size 0x10
  memory RVCT4: ROM 0x8000000 size 0x7000
  memory RVCT9: RAM 0x20000000 size 0x10000
  link misc: --diag_suppress=L6329
  group Application/MDK-ARM
    ./: startup_stm32f105xc.s
  group Middlewares/USB_Device_Library
    ../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_ctlreq.c usbd_ioreq.c usbd_core.c
    ../Middlewares/ST/STM32_USB_Device_Library/Class/CustomHID/Src/: usbd_customhid.c
  group Drivers/CMSIS
    ../Src/: system_stm32f1xx.c
  group Application/User
    ../Src/: stm32f1xx_it.c gpio.c stm32f1xx_hal_msp.c usb_device.c usbd_desc.c usbd_conf.c usbd_custom_hid_if.c main.c update.c FlashProgram.c hex.c USB_Comm.c
    ../Inc/: LSP.h
    ../../../../Dropbox/Crux Projects/CommonLibraries/: RingBuff.c mTimers.c GPIO_Ports.c aes.c ascii_to_hex.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_tim.c stm32f1xx_hal_gpio.c stm32f1xx_hal_pcd_ex.c stm32f1xx_hal_dma.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_pcd.c stm32f1xx_ll_usb.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_cortex.c stm32f1xx_hal_flash.c
software components: CMSIS:CORE 5.0.2
